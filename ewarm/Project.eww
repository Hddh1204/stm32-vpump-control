<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DegasPump_STM32G070RB.ewp</path>
  </project>
  <batchBuild />
</workspace>
